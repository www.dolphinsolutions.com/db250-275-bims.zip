Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2019-04-23T14:06:25
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 14:06:25 2019 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{995430D9-1A53-4676-8E5C-9FFC997D5086}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 14:06:23 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 14:06:24 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 14:06:24 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: P:\Fastrack\53721_DOLPHIN SOLUTIONS LIMITED\ADDITIONAL DRAWINGS 2019 BIM\04$APRIL\DB250 - DB275.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 2 Default: yes; Symbol at End 1 Default: no; Line Weight: 1; Line Pattern: -3000010; Color: 0

# IfcBuildingElementProxy: DB250 / DB275 Dolphin Electronic Infrared Tap with Temperature Adjustment Lever, DB250 - DB275:DB250 / DB275 Dolphin Electronic Infrared Tap with Temperature Adjustment Lever:15986
In: Level 1
Material: Cold, Stainless Steel, Hot, Glass
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.000256577 m3; Height: 142mm; Width: 50mm Diameter; Projection: 104mm
Pset_ManufacturerTypeInformation - Manufacturer: Dolphin Solutions Ltd.
Pset_BuildingElementProxyCommon - Reference: DB250 / DB275 Dolphin Electronic Infrared Tap with Temperature Adjustment Lever
Identity Data - Manufacturer: Dolphin Solutions Ltd.; Assembly Description: Other Plumbing Fixtures; Address: Southpoint, Compass Park, Junction Road Bodiam, TN32 5BS; Description: Electronic infrared tap with temperature adjustment lever; URL: www.dolphinsolutions.co.uk; Assembly Code: D2010900; Tel No.: +44 (0) 1424 202 224; Email: info@dolphinsolutions.co.uk; Fax No.: +44 (0) 1424 205 200; Model: DB250 / DB275
Electrical - Power Source: 9V Battery / Plug-in 9V transformer (Tap: male / Power source female); Power Connections: Tap: male / Power source: female
Other - BREEAM compliant: yes; WRAS approved: yes
General - Product Page Link: https://www.dolphinsolutions.co.uk/product/electronic-infrared-tap-with-temperature-adjustment-lever-2; SKA compliant: yes; Warranty: 2 years; Product Data: Touch Free Tap - for ultimate hygiene - prevents cross contamination. Quality poliished or brushed chrome plated brass finishes available from stock - other finishes available to special order. Water Supply: hot and cold supply with temperature adjustment lever. Flow rate - 3.8 litres/minute with Dolphin standard fitted flow regulator at any pressure between 0 and 6 bar (other flow rates available to special order). Flow time once user's hands are removed from the tap - 1 second (adjustable by using remote control DB51). Interchangeable STD M22/24 Neoperl Aerator insert. 3/8" BSP water supply connector. Tap settings including optional hygiene flush can be adjusted by using remote control (BD51). Mandatory Hygiene Flush feature can be specified to combat Legionella. WRAS approved. 2 years manufacturer's warranty. Complies with SKA rating criteria. The two flexible connectors contain integral check (non-return) valves. Dolphin recommend their Dolphin Blue DB61 TMV3 be used in conjunction with this Dolphin Blue tap. Dolphin low flow taps are fully BREEAM compliant and contribute to up to five BREEAM WAT 1 credits.
Plumbing - Water supply connector: 3/8" BSP; Maximum water temperature: 70°C
